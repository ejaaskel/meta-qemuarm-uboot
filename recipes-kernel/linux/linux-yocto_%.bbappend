FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = "file://enable_tpm.cfg"
